<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Boot</name>
    <file>
      <name>$PROJ_DIR$\user\reboot.S</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\boot\startup_LPC17xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\boot\system_LPC17xx.c</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\Libs\src\debug_frmwrk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_clkpwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_emac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_gpdma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_iap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_libcfg_default.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_mcpwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_nvic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_pinsel.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_qei.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_rit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_ssp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libs\src\lpc17xx_wdt.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\user\Boot.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\download.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\ymodem.c</name>
    </file>
  </group>
</project>


